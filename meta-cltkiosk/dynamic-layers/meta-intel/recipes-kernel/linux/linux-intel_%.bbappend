FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SOURCES:append = " \
	file://wireguard.cfg \
"